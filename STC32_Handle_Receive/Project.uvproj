# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: Project +hex
  group HardWare
    ./HardWare/Source/: BEEP.c DHT11.c HC595.c KEY.c MOTOR.c NRF24L01.c SERVO.c SPI.c ULTRASONIC.c oled.c MP3_TF_16P.c WS2812.c
  group System
    ./System/: USART.c Delay.c PWM.c
  group User
    ./User/: main.c NRFDATA.c
